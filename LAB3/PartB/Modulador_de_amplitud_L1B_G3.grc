options:
  parameters:
    author: L1B_G3
    generate_options: qt_gui
    id: Modulador_de_amplitud_L1B_G3
    output_language: python
    title: Modulador de amplitud_L1B_G3
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitu de portadora
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.250'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Habilita Portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: Vol
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '1'
    step: '1'
    stop: '50'
    value: '1'
  states: {state: disabled}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuancia del mensaje
    start: '0'
    step: '100'
    stop: samp_rate
    value: '1000'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    I_vect: '1024'
  states: {state: disabled}
- name: EnvolventeComplejaSSB_0
  id: EnvolventeComplejaSSB
  parameters:
    Ac: Ac
    B: B
    K: K
  states: {}
- name: Modulador_AM_L1B_0
  id: Modulador_AM_L1B
  parameters:
    Ac: Ac
    ka: K
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/lab_comu_I_L1B/Demas/session52_quevedobzrp.wav-20230412T155609Z-001/session52_quevedobzrp.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: audio_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: audio_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaSSB_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeComplejaSSB_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', EnvolventeComplejaSSB_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
