options:
  parameters:
    category: '[Modulos_L1B_G3]'
    generate_options: hb_qt_gui
    id: CalculoPotenciaComunicaciones
    output_language: python
    title: CalculoPotenciaComunicaciones
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: I_vect
  id: parameter
  parameters:
    label: longitud FFT
    type: intx
    value: '1024'
  states: {}
- name: Modulos_J1A_g2_SumaVector_0
  id: Modulos_J1A_g2_SumaVector
  parameters:
    PARAM1: I_vect
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: I_vect
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*135115.625)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: I_vect
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: I_vect
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: potencia
    name: PotenciaLogaritmica dBm
    type: float
    unit1: (dBm)
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: potencia
    name: PotenciaLineal W
    type: float
    unit1: W
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: potencia
    name: PotenciaLogaritmica dBW
    type: float
    unit1: (dBW)
  states: {}

connections:
- [Modulos_J1A_g2_SumaVector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', Modulos_J1A_g2_SumaVector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
